Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-02-01T13:03:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Feb 01 13:03:34 2018* Host: NCL-PI12* Database: C:\Users\KunduR\AppData\Local\Temp\{87C52B73-2657-4EC9-8E50-20335051E88E}\ifc* Database version: 5507* Database creation date: Thu Feb 01 13:03:30 2018* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Feb 01 13:03:31 2018* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Feb 01 13:03:31 2018* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: Ryno Tub Chair, NBS_PineappleContracts_DmstcChrs_RynoTubChair:Ryno Tub Chair:291195
In: Level 0
Type - ElementType: Ryno Tub Chair; Classification: Pr_40_50_12_22 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_PineappleContracts_DomesticChairs_RynoTubChair; ManufacturerName: Pineapple Contracts; NBSCertification: www.nationalbimlibrary.com/cert/5pyz5nyl; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: www.pineapplecontracts.com/products/challenging-environment-furniture/10/ryno-tub-chair/271; Revision: n/a; Uniclass2015Title: Dining chairs; Uniclass2015Code: Pr_40_50_12_22; Uniclass2015Version: Products v1.13; Version: 3
Type - NBS_Data - SeatsAndBacksMaterial: Polyethylene; SeatsAndBacksFinish: n/a; SeatsAndBacksColour: n/a; FramesMaterial: Polyethylene; FramesFinish: Shot-peen surface finish; FramesColour: n/a
Type - Pset_FurnitureTypeChair - HighestSeatingHeight: 0 mm; LowestSeatingHeight: 0 mm; SeatingHeight: 430 mm
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: CHAIR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Moveable; Category: Pr_40_50_12_22:Dining chairs; CodePerformance: UL 94 HB, BS EN 16139:2013 level 2, BS 5852:2006 source 5; Color: Epic blue, icon purple, blaze orange, vegas yellow, lime green, cool green, granite, moonwalk grey, thunder grey, black; Constituents: n/a; Description: Ryno tub chair is designed for challenging and high traffic areas. It is ideal for indoor as well as outdoor use [when used without seat pad]; DurationUnit: year; ExpectedLife: Lifetime [except seat pad]; Features: Anti-microbial polyethylene additive, UV stabilised and water-resistant, Heavy duty linking and floor anchor brackets available, Optional matching upholstered seat; Finish: Shot-peen surface finish; Grade: n/a; Manufacturer: sales@pineapplecontracts.com; Material: Chair - Polyethylene, Seat pad - Plywood, foam, fabric; ModelNumber: n/a; ModelReference: Ryno Tub Chair; Name: DomesticChairs_RynoTubChair_PineappleContracts; NominalHeight: 802 mm; NominalLength: 674 mm; NominalWidth: 666 mm; ReplacementCost: n/a; Shape: n/a; Size: 680 x 666 x 803 mm; SustainabilityPerformance: 100% recyclable; excluding seat pad; WarrantyDescription: Ryno tub supplied by pineapple contracts is guaranteed with lifetime warranty against faulty materials or workmanship; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: customer.care@pineapplecontracts.com
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
